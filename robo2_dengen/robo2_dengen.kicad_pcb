# Repository hakoroboken/2024_R2_dengenkiban

File README.md:

# 2024_R2_dengenkiban
全国のロボ2に使った電源基板

## KiCad design robo2_dengen/robo2_dengen.kicad_pcb

Parts:
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13: Conn_01x02_Pin; xt30_2hole

Connections:
+BATT: J1.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1
GND: J6.2, J9.2, J10.2, J11.2, J12.2, J13.2
unnamed: J1.2, J2.1
unnamed: J2.2, J3.1
unnamed: J3.2, J4.1
unnamed: J4.2, J5.1
gnd: J5.2, J6.1, J7.2, J8.2

Notes on the sheet:
電圧計
LiPo
ヒューズ
モータ
マイコン
緊急停止
主電源

Board: 2 copper layers, 12 parts (0 on the bottom side), 7 nets, no tracks yet.

## Commit log

2024-12-05 readme_tuiki
